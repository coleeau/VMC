B_ReadKey:				JMP	BI_ReadKey				;$FF00
B_TIME_Delay:			JMP BI_TIME_Delay			;$FF03
B_TIME_Pulse:			JMP B_Panic					;$FF06
B_TIME_Pulse_Mute:		JMP B_Panic					;$FF09
B_I2C:					JMP BI_I2C					;$FF0C
B_I2C_Reserved:			JMP B_Panic					;$FF0F
B_COMM_RX_Char:			JMP BI_COMM_RX_Char			;$FF12
B_COMM_RX_Str:			JMP BI_COMM_RX_Str			;$FF15
B_COMM_TX_Char:			JMP BI_COMM_TX_Char			;$FF18
B_COMM_TX_Str:			JMP BI_COMM_TX_Str			;$FF1B
B_COMM_MoveCsr:			JMP BI_COMM_MoveCsr			;$FF1E
B_COMM_ClsScr:			JMP BI_COMM_ClsScr			;$FF21
B_COMM_Set_Speed:		JMP BI_COMM_Set_Speed		;$FF24
B_COMM_Setup:			JMP B_Panic					;$FF27
B_COMM_Setup_Fifo:		JMP B_Panic					;$FF2A
B_COMM_Setup_Modm:		JMP B_Panic					;$FF2D
B_COMM_Reserved1:		JMP B_Panic					;$FF30
B_COMM_Reserved2:		JMP B_Panic					;$FF33
B_BANKSW_RAM:			JMP BI_BANKSW_RAM			;$FF36
B_BANKSW_VRAM:			JMP BI_BANKSW_VRAM			;$FF39
B_BANKSW_V_CHRAM:		JMP BI_BANKSW_V_CHRAM		;$FF3C
B_BANKSW_CHRAM:			JMP BI_BANKSW_CHRAM			;$FF3F
B_BANKSW_ROM:			JMP BI_BANKSW_ROM			;$FF42
B_BANKSW_RESERVED:		JMP B_Panic					;$FF45
B_MATH8_Mult:			JMP BI_MATH8_Mult			;$FF48
B_MATH8_Div:			JMP BI_MATH8_Div			;$FF4B
B_MATH8_Nybble_Swap:	JMP BI_MATH8_Nybble_Swap	;$FF4E
B_MATH16_Add:			JMP BI_MATH16_Add			;$FF51
B_MATH16_Sub:			JMP BI_MATH16_Sub			;$FF54
B_MATH16_Multi:			JMP BI_MATH16_Multi			;$FF57
B_MATH16_Div:			JMP BI_MATH16_Div			;$FF5A
B_DATA_RLE_Encode:		JMP BI_DATA_RLE_Encode		;$FF5D
B_DATA_RLE_Decode:		JMP BI_DATA_RLE_Decode		;$FF60
B_DATA_LZS_Encode:		JMP BI_DATA_LZS_Encode		;$FF63
B_DATA_LZS_Decode:		JMP BI_DATA_LZS_Decode		;$FF66
B_DATA_Copy:			JMP BI_DATA_Copy			;$FF69
B_DATA_EEPROM_Write:	JMP BI_DATA_EEPROM_Write	;$FF6C
B_Data_Hex2ASC:			JMP BI_Data_Hex2ASC			;$FF6F
B_VER:					JMP BI_VER					;$FF72
B_IRQ_Disable:			JMP BI_IRQ_Disable			;$FF75